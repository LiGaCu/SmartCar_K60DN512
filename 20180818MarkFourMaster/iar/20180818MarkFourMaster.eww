<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\20180818MarkFourMaster_K60DZ10.ewp</path>
  </project>
  <batchBuild></batchBuild>
</workspace>